Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-09-13T14:51:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 13 14:51:57 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\f13ad2b0-5f87-41b9-8590-51be414afd43\a7372bb9-4be7-46ae-a090-fbd652eaf223\ifc * Database version: 5507 * Database creation date: Tue Sep 13 14:51:56 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 13 14:51:57 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 13 14:51:57 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11744550_EU_PRI214EL_STW:53214004_EU_11744550_PRI214EL_STW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 53214004_EU_11744550_PRI214EL_STW
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 53214004_EU_11744550_PRI214EL_STW
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Eisengrau, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Design_Glass Black
Pset_BuildingElementProxyCommon - sets with these values: 2
